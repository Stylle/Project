# Keil uVision project Learning.uvprojx, settings and files
target Study (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Temp +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10x_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\User;..\STM32F103RC_LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HANDWARE\EXIT;..\HANDWARE\KEY;..\HANDWARE\LED;..\HANDWARE\KEY4X4;..\HANDWARE\M7SEG;..\HANDWARE\BEEP;..\HANDWARE\KEY;..\HANDWARE\UART;..\HANDWARE\ESP8266;..\SYSTEM\timer;..\HANDWARE\TTP223;..\HANDWARE\TIM2;..\HANDWARE\SG90;..\HANDWARE\TIM3;..\HANDWARE\74HC595;..\HANDWARE\ULN2003;..\HANDWARE\L298N;..\HANDWARE\24CXX;..\HANDWARE\IIC;..\HANDWARE\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Lib
    ../STM32F103RC_LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/timer/: timer.c
    ../HANDWARE/IIC/: myiic.c
    ../HANDWARE/24CXX/: 24cxx.c
  group HANDWARE
    ../HANDWARE/LED/: LED.c
    ../HANDWARE/BEEP/: BEEP.c
    ../HANDWARE/KEY/: KEY.c
    ../HANDWARE/ESP8266/: ESP8266.c
    ../HANDWARE/UART/: usart3.c
    ../HANDWARE/KEY4X4/: KEY4X4.c
    ../HANDWARE/TTP223/: TTP223.c
    ../HANDWARE/TIM2/: TIM2.c
    ../HANDWARE/SG90/: SG90.c
    ../HANDWARE/TIM3/: TIM3.c
    ../HANDWARE/M7SEG/: M7SEG.c
    ../HANDWARE/ULN2003/: ULN2003.c
    ../HANDWARE/L298N/: L298N.c
    ../HANDWARE/OLED/: oled.c
  group README
    ../README/: Readme.txt
